## my-package/Config.in.host
```kconfig
config BR2_PACKAGE_HOST_MY_PACKAGE
    bool "my package"
    help
      Demonstrate buildroot development workflow.
```
